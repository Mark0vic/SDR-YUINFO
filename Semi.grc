options:
  parameters:
    generate_options: qt_gui
    id: Semi
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: SR
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: SR*10
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: SR
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: 10*SR
    tau: '75e-6'
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (1, 1)
    type: float
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /home/katedratii/Desktop/MArkovic/semi/prijem.wav
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: SR
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/katedratii/Desktop/Markovic/semi/dmnds.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 5e5
    center_freq0: 675e6
    gain0: '-30'
    samp_rate: 5e5
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: 5e5
    center_freq0: 700e6
    gain0: '-30'
    samp_rate: 5e5
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_stream_demux_0, '0']
- [analog_wfm_tx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', analog_wfm_tx_0, '0']
- [blocks_stream_demux_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_stream_demux_0, '1', blocks_wavfile_sink_0, '1']
- [blocks_stream_mux_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_stream_mux_0, '0']
- [blocks_wavfile_source_0, '1', blocks_stream_mux_0, '1']
- [uhd_usrp_source_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
